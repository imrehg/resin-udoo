include resin-image.inc

### TEST
# we add bootloader to the flasher boot partition so we can burn it to SPI ROM
#RESIN_BOOT_PARTITION_FILES_append_udoo-quad = " u-boot-${MACHINE}.imx:"

