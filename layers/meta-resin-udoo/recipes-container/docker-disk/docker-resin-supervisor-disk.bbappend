SUPERVISOR_REPOSITORY_udoo = "resin/armv7hf-supervisor"
